# Keil uVision project LASER_STC.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H4K64TL Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x0FFF) IROM(0-0xFFF8) CLOCK(45000000)
  output: LASER_STC +hex
  c flags: Optimize=2 SizeSpeed=1
  c include: ..\DRIVER;..\USER
  group SOURCE
    ./: STARTUP.A51
  group DRIVER
    ../DRIVER/: STC8G_H_GPIO.c delay.c uart.c key.c laser.c NE2.c systick.c cmd_queue.c modbus.c app.c irq_guard.c st7789.c ui.c font_ascii_8x16.c dht11.c
  group USER
    ../USER/: main.c
